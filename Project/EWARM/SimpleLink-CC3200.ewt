<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\..\Source\main.c</name>
    </file>
  </group>
  <group>
    <name>Bsp</name>
  </group>
  <group>
    <name>Doc</name>
  </group>
  <group>
    <name>Library</name>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\camera.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\cpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\des.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\hwspinlock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\i2s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\pin.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\prcm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\sdhost.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\shamd5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\systick.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\udma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\utils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\driverlib\wdt.c</name>
    </file>
  </group>
  <group>
    <name>Startup</name>
    <file>
      <name>$PROJ_DIR$\..\..\Library\cc32xx\startup\startup_ewarm.c</name>
    </file>
  </group>
</project>


