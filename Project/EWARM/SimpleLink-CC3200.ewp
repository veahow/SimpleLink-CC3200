# IAR project SimpleLink-CC3200.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_FULL; SL_PLATFORM_MULTI_THREADED
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../; ../../Library/cc32xx/; ../../Library/cc32xx/inc/; ../../Library/cc32xx/driverlib/; ../../Library/cc32xx/startup/; ../../Source/freertos/; ../../Source/freertos/source/; ../../Source/freertos/source/include/; ../../Source/freertos/source/portable/IAR/ARM_CM4/; ../../Source/network/simplelink/; ../../Source/network/simplelink/source/; ../../Source/network/simplelink/include/; ../../Source/network/simplelink_extlib/provisioninglib/; ../../Source/network/netapps/mqtt/client/; ../../Source/network/netapps/mqtt/common/; ../../Source/network/netapps/mqtt/include/; ../../Source/network/netapps/mqtt/platform/; ../../Source/network/netapps/mqtt/sl/; ../../Source/myapi/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../Source/freertos/source/; ../../Source/freertos/source/portable/IAR/ARM_CM4/
  OBJCOPY.OOCOutputFile: SimpleLink-CC3200.bin
  ILINK.IlinkOutputFile: SimpleLink-CC3200.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../Source/: main.c
  group Bsp
    ../../Source/myapi/: adc_if.c global.c gpio_if.c i2c_if.c pinmux.c pwm_if.c sensor.c spi_if.c uart_if.c
  group Bsp/Wi-Fi
    ../../Source/myapi/: network.c transport.c
  group FreeRTOS
    ../../Source/freertos/: osi_freertos.c
  group FreeRTOS/Source
    ../../Source/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Source/freertos/source/portable/MemMang/: heap_3.c
    ../../Source/freertos/source/portable/IAR/ARM_CM4/: port.c portasm.s
  group Library
    ../../Library/cc32xx/driverlib/: adc.c aes.c camera.c cpu.c crc.c des.c flash.c gpio.c hwspinlock.c i2c.c i2s.c interrupt.c pin.c prcm.c sdhost.c shamd5.c spi.c systick.c timer.c uart.c udma.c utils.c wdt.c
  group Network/SimpleLink
    ../../Source/network/simplelink/: cc_pal.c
    ../../Source/network/simplelink/source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
  group Network/SimpleLink_extlib/Provisioninglib
    ../../Source/network/simplelink_extlib/provisioninglib/: cfg_confirm.c events_handler.c networkListHndl.c provisioning_logic.c
  group Startup
    ../../Library/cc32xx/startup/: startup_ewarm.c
